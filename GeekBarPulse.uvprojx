# Keil uVision project GeekBarPulse.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GeekBarPulse +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, PY32F030x8
  c include: .\Core\Inc;..\..\Downloads\PY32F0xx_Firmware-master\PY32F0xx_Firmware-master\Drivers\PY32F0xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Src
    ./Core/Src/: main.c py32f0xx_hal_msp.c py32f0xx_it.c display.c leds.c battery.c scheduler.c ui.c exti.c slide_switch.c
    ../../Downloads/PY32F0xx_Firmware-master/PY32F0xx_Firmware-master/Drivers/CMSIS/Device/PY32F0xx/Source/: system_py32f0xx.c
    ../../Downloads/PY32F0xx_Firmware-master/PY32F0xx_Firmware-master/Drivers/CMSIS/Device/PY32F0xx/Source/arm/: startup_py32f030x8.s
  group PY32F0xx_HAL_Driver
    ./PY32F0xx_HAL_Driver/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c
  group Inc
    ./Core/Inc/: main.h py32f0xx_hal_conf.h py32f0xx_it.h display.h leds.h gpio_defines.h battery.h scheduler.h ui.h exti.h slide_switch.h
software components: CMSIS:CORE 6.2.0
